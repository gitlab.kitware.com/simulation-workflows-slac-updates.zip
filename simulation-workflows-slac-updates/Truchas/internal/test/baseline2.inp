Generated by CMB

&MESH
  mesh_file                 = "/media/ssd/sim/cmb_core/gitlab/smtk-testing-data/exodus/sx_bar_hex.exo"
/

&OUTPUTS
  output_t   = 0.0, 1.0
  output_dt  = 0.1
/

&ENCLOSURE
  name                      = "furnace"
  mesh_file                 = "/media/ssd/sim/cmb_core/gitlab/smtk-testing-data/exodus/sx_bar_hex.exo"
  symmetries                = MirrorX, MirrorZ, RotZ4
  side_set_ids              = 1, 3, 7, 8, 9, 10, 11, 15, 17, 19, 23
  moving_enclosure          = .true.
  displacement_set_ids      = 3, 11, 15, 23
  displacement_sequence = 
    0.000000, 0.000000, 0.000000,
    0.000000, 0.000000, -0.010000,
    0.000000, 0.000000, -0.020000
  enclosure_file_sequence_prefix = "genre/rad_"
  ignore_block_ids          = 2
/

&ENCLOSURE_RADIATION
  name                      = "furnace"
  ambient_constant          = 20.0
  error_tolerance           = 0.0001
  moving_enclosure          = .true.
  linear_interpolation      = .true.
  skip_geometry_check       = .true.
  enclosure_file_sequence_prefix = "genre/rad_"
  time_sequence = 
    0.000000,
    236.220000,
    472.441000
/

&ENCLOSURE_SURFACE
  name                      = "Moving Surfaces"
  enclosure_name            = "furnace"
  face_block_ids            = 3, 11, 15, 23
  emissivity                = 0.789
/

&ENCLOSURE_SURFACE
  name                      = "Stationary Surfaces"
  enclosure_name            = "furnace"
  face_block_ids            = 1, 7, 8, 9, 10, 17, 19
  emissivity                = 0.876
/

&PHYSICS
  fluid_flow                = .false.
  heat_transfer             = .true.
/

&DIFFUSION_SOLVER
  stepping_method           = "Adaptive BDF2"
  abs_enthalpy_tol          = 0.0
  rel_enthalpy_tol          = 0.001
  abs_temp_tol              = 0.0
  rel_temp_tol              = 0.001
  nlk_preconditioner        = "Hypre_AMG"
  max_nlk_itr               = 6
  max_nlk_vec               = 2
  nlk_tol                   = 0.05
  nlk_vec_tol               = 0.001
  verbose_stepping          = .true.
  pc_amg_cycles             = 1
/

&CHAPARRAL
  blocking_enclosure        = .true.
  partial_enclosure         = .false.
  bsp_max_tree_depth        = 10
  bsp_min_leaf_length       = 25
  spatial_tolerance         = 1e-08
  hemicube_resolution       = 60
  min_separation            = 15.0
  max_subdivisions          = 60
  smoothing_tolerance       = 1e-08
  smoothing_max_iter        = 100
  smoothing_weigth          = 2
  verbosity_level           = 0
/

&NUMERICS
  dt_init                   = 1e-06
  dt_grow                   = 1.05
  dt_max                    = 10.0
  dt_min                    = 1e-06
  t                         = 0.0
/

&PHYSICAL_CONSTANTS
  absolute_zero             = -273.15
  stefan_boltzmann          = 5.67e-08
/
