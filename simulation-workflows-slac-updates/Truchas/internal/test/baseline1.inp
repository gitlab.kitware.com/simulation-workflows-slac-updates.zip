Generated by CMB

&MESH
  mesh_file                 = "/media/ssd/sim/cmb_core/gitlab/smtk-testing-data/exodus/disk_out_ref.ex2"
  exodus_block_modulus      = 10000
  interface_side_sets       = 4
/

&OUTPUTS
  output_t   = 0.0, 1.0, 5.0, 999.9
  output_dt  = 0.02, 0.1, 0.2
/

&PHYSICS
  fluid_flow                = .true.
  heat_transfer             = .true.
  body_force                = 0.0, 0.0, -32.2
  inviscid                  = .false.
/

&MATERIAL
  material_name             = "Aluminum 6061-T6 - solid"
  material_number           = 1
  immobile                  = .false.
  density                   = 2700.0
/

&PHASE
  name = "Aluminum 6061-T6 - solid"
  property_name(1) = "density",       property_constant(1) = 2700.0
  property_name(2) = "specific heat", property_constant(2) = 896.0
  property_name(3) = "conductivity",  property_constant(3) = 167.0
/

&MATERIAL
  material_name             = "Aluminum 6061-T6 - fluid"
  material_number           = 2
  immobile                  = .false.
  density                   = 2700.0
/

&PHASE
  name = "Aluminum 6061-T6 - fluid"
  property_name(1) = "density",       property_constant(1) = 2700.0
  property_name(2) = "specific heat", property_constant(2) = 896.0
  property_name(3) = "conductivity",  property_constant(3) = 167.0
  property_name(4) = "viscosity",     property_function(4) = "Al viscosity"
/

&MATERIAL_SYSTEM
  name                      = "Aluminum 6061-T6"
  phases                    = "Aluminum 6061-T6 - solid", "Aluminum 6061-T6 - fluid"
  transition_temps_low      = 582.0
  transition_temps_high     = 652.0
  latent_heat               = 321.0
/

&MATERIAL
  material_name             = "Void Material"
  material_number           = 3
  immobile                  = .false.
  density                   = 0.0
  void_temperature          = 20.0
  sound_speed               = 0.0
  material_feature          = "background"
/

&DIFFUSION_SOLVER
  stepping_method           = "Non-adaptive BDF1"
  residual_atol             = 0.0
  residual_rtol             = 1e-08
  nlk_preconditioner        = "Hypre_AMG"
  max_nlk_itr               = 5
  max_nlk_vec               = 4
  nlk_vec_tol               = 0.001
  verbose_stepping          = .true.
  pc_amg_cycles             = 1
  cond_vfrac_threshold      = 0.001
/

&NUMERICS
  dt_init                   = 1e-06
  dt_grow                   = 1.05
  dt_max                    = 10.0
  dt_min                    = 1e-06
  t                         = 0.0
  discrete_ops_type         = "default"
  projection_linear_solution = "projection-linear-solver"
  viscous_implictness       = 0.0
  viscous_linear_solution   = "viscous-linear-solver"
  viscous_number            = 5.0
  volume_track_subcycles    = 2
  body_force_implicitness   = 0.5
  mass_limiter              = .true.
  mass_limiter_cutoff       = 2.5e-05
  mechanical_energy_bound   = 0.0
  momentum_solidify_implicitness = 0.0
/

&LINEAR_SOLVER
  name                      = "projection-linear-solver"
  method                    = "fgmres"
  preconditioning_method    = "ssor"
  preconditioning_steps     = 2
  relaxation_parameter      = 1.4
  stopping_criterion        = "||r||"
  convergence_criterion     = 1e-08
  krylov_vectors            = 50
  output_mode               = "none"
/

&LINEAR_SOLVER
  name                      = "viscous-linear-solver"
  method                    = "fgmres"
  preconditioning_method    = "diagonal"
  preconditioning_steps     = 2
  relaxation_parameter      = 1.0
  stopping_criterion        = "||r||/||b||"
  convergence_criterion     = 1e-08
  krylov_vectors            = 50
  output_mode               = "none"
/

&DS_BOUNDARY_CONDITION
  name                      = "Thermal BC::htc"
  condition                 = "htc"
  face_set_ids              = 1
  data_constant             = 0.543, 212.5
/

&DS_BOUNDARY_CONDITION
  name                      = "Thermal BC::radiation"
  condition                 = "radiation"
  face_set_ids              = 1
  data_constant             = 0.888, 32.2
/

&DS_INTERFACE_CONDITION
  name                      = "Thermal Interface"
  condition                 = "htc"
  face_set_ids              = 4
  data_constant             = 0.123
/

&BC
  bc_name                   = "Pressure BC"
  bc_variable               = "pressure"
  bc_type                   = "dirichlet"
  surface_name              = "from mesh file"
  mesh_surface              = 2
  bc_value                  = 73.73
  inflow_material           = "Aluminum 6061-T6"
  inflow_temperature        = 707.7
/

&BC
  bc_name                   = "Velocity BC"
  bc_variable               = "velocity"
  bc_type                   = "dirichlet"
  surface_name              = "from mesh file"
  mesh_surface              = 3
  bc_value                  = 1.1, 2.2, 3.3
/

&BODY
  surface_name              = "from mesh file"
  mesh_material_number      = 1
  material_number           = 2
  temperature               = 98.6
  velocity                  = 0.0, 0.0, 0.0
/

&DS_SOURCE
  equation                  = "temperature"
  cell_set_ids              = 1
  source_function           = "Source Function"
/

&PROBE
  probe_name                = "Probe 1"
  probe_description         = "Descriptive phrase goes here..."
  probe_coords              = 3.14159, -0.111, 2.54
/

&SIMULATION_CONTROL
  phase_start_times         = 0.0, 20.0
  phase_init_dt_factor      = 0.01
/

&FUNCTION
  name                      = "Al viscosity"
  type                      = "tabular"
  table                     = 
    662.0, 1379.0,
    669.0, 1364.0,
    769.0, 1339.0,
    685.0, 1324.0,
    689.0, 1317.0,
    700.0, 1268.0,
    718.0, 1250.0,
    768.0, 1175.0,
    806.0, 1102.0,
    833.0, 1028.0
/

&FUNCTION
  name                      = "Source Function"
  type                      = "tabular"
  table                     = 
    100.0, 100.001,
    200.0, 200.002,
    300.0, 300.003
/

&PHYSICAL_CONSTANTS
  absolute_zero             = 0.0
  stefan_boltzmann          = 5.67e-08
/
